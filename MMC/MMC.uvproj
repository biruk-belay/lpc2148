# Keil uVision project MMC.uvproj, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: MMC +hex
  c flags: OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s printf.cpp main.cpp printf.h SD.h spi.h SD.cpp spi.cpp
    ../ADC/: lib.cpp lib.h
